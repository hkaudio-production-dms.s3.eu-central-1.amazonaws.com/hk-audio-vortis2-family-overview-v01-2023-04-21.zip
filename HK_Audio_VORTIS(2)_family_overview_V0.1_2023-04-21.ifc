Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-04-21T16:52:20
Written by: IFC-manager for SketchUp (4.1.5)
Made in: SketchUp 2021 (21.0.339)

# IfcBuildingElementProxy: Gruppe#10
In: default building storey
Material: Default

# IfcBuildingElementProxy: Gruppe#11
In: default building storey
Material: Default

# IfcBuildingElementProxy: Gruppe#14
In: default building storey
Material: Default

# IfcBuildingElementProxy: Gruppe#15
In: default building storey
Material: Default

# IfcBuildingElementProxy: Gruppe#17
In: default building storey
Material: Default

# IfcBuildingElementProxy: Gruppe#18
In: default building storey
Material: Default

# IfcBuildingElementProxy: Gruppe#2 (3)
In: default building storey
Material: Default

# IfcBuildingElementProxy: Gruppe#3 (4)
In: default building storey
Material: Default

# IfcBuildingElementProxy: Gruppe#4 (3)
In: default building storey
Material: Default

# IfcBuildingElementProxy: Gruppe#5 (3)
In: default building storey
Material: Default

# IfcBuildingElementProxy: Gruppe#6
In: default building storey
Material: Default

# IfcBuildingElementProxy: Gruppe#7
In: default building storey
Material: Default

# IfcBuildingElementProxy: Gruppe#8
In: default building storey
Material: Default

# IfcBuildingElementProxy: Gruppe#9
In: default building storey
Material: Default

# IfcBuildingElementProxy: HK_Audio_VORTIS(2)_TB-R_Tilt-bracket
In: default building storey
Material: Default

# IfcBuildingElementProxy: HK_Audio_VORTIS(2)_Tilt_Unit_Adjuster (3)
In: default building storey
Material: Default

# IfcBuildingElementProxy: HK_Audio_VORTIS(2)_VR(2)-10810_(TR)_U-bracket_with_Tilt_Unit
In: default building storey
Material: Default

# IfcBuildingElementProxy: HK_Audio_VORTIS(2)_VR(2)-11210
In: default building storey
Material: Default

# IfcBuildingElementProxy: HK_Audio_VORTIS(2)_VR(2)-11214
In: default building storey
Material: Default

# IfcBuildingElementProxy: HK_Audio_VORTIS(2)_VR(2)-11510
In: default building storey
Material: Default

# IfcBuildingElementProxy: HK_Audio_VORTIS(2)_VR(2)-11514
In: default building storey
Material: Default

# IfcBuildingElementProxy: HK_Audio_VORTIS(2)_VR(2)-21214
In: default building storey
Material: Default

# IfcBuildingElementProxy: HK_Audio_VORTIS(2)_Wall_Mount_Plate (2)
In: default building storey
Material: Default

# IfcBuildingElementProxy: VR(2) Tilt Unit
In: default building storey
Material: Default

# IfcBuildingElementProxy: VR(2) Tilt Unit with U-bracket (example)
In: default building storey
Material: Default

# IfcBuildingElementProxy: VR(2) Wall Mount Plate with Tilt Unit and U-bracket (example)
In: default building storey
Material: Default

# IfcBuildingElementProxy: VR(2)-10810 (TR)
In: default building storey
Material: Default

# IfcBuildingElementProxy: VR(2)-10810 (TR) U-bracket (4)
In: default building storey
Material: Default

# IfcBuildingElementProxy: VR(2)-11210 U-bracket
In: default building storey
Material: Default

# IfcBuildingElementProxy: VR(2)-11214 U-bracket
In: default building storey
Material: Default

# IfcBuildingElementProxy: VR(2)-11510 U-bracket
In: default building storey
Material: Default

# IfcBuildingElementProxy: VR(2)-11514 U-bracket
In: default building storey
Material: Default

# IfcBuildingElementProxy: VR(2)-21214 U-bracket
In: default building storey
Material: Default
